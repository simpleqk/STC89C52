# Keil uVision project II2C.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: II2C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c DelayMs.A51 DelayMs.h I2C.c I2C.h AT24C02.c AT24C02.h LCD1602.c LCD1602.h
