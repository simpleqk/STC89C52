# Keil uVision project Temperature.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Temperature +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c DelayMs.A51 DelayMs.h LCD1602.c LCD1602.h OneWire.c OneWire.h DS18B20.c DS18B20.h
