# Keil uVision project ADDA.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ADDA +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c I2C.c I2C.h PCF8591.c PCF8591.h LCD1602.c LCD1602.h DelayMs.A51 DelayMs.h
